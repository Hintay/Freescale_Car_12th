# IAR project vcan_Kinetis.ewp, settings and files
configuration FN15_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; IAR; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: ..\..\App\Inc\; ..\..\Board\inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vcan_Kinetis.hex
  ILINK.IlinkOutputFile: vcan_Kinetis.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FN15_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: vcan_Kinetis.srec
configuration FX15_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
configuration FX15_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration DZ10_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
configuration DZ10_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../../App/: DialSwitch.c DialSwitch.h findtrack.c LcdDisplay.c LcdDisplay.h main.c MK60_conf.c MK60_it.c motor.c steer.c Test.c TrackType.c TrackType.h ZJGM_Crotrol.c
    ../../App/Inc/: findtrack.h MK60_conf.h MK60_it.h motor.h PORT_cfg.h steer.h Test.h ZJGM_Crotrol.h
    ../../Board/src/: VCAN_LCD.c
  group Board
    ../../Board/src/: VCAN_ASCII.c VCAN_BMP.c VCAN_camera.c VCAN_computer.c vcan_img2sd.c VCAN_key.c VCAN_key_event.c VCAN_LCD_CH.c VCAN_LCD_ILI9341.c VCAN_LCD_ST7735R.c VCAN_LCD_ST7735S.c VCAN_LED.C VCAN_MMA7455.c VCAN_NRF24L0.c VCAN_NRF24L0_MSG.c VCAN_OV7725_Eagle.c VCAN_OV7725_Wolf.c VCAN_RTC_count.C VCAN_SCCB.c vcan_sd_app.c Vcan_touch.c VCAN_TSL1401.c VCAN_UI_VAR.c
  group Chip
    ../../Chip/inc/: common.h
    ../../Chip/src/: misc.c MK60_adc.c MK60_can.c MK60_dac.c MK60_dma.c MK60_DWT.c MK60_flash.c MK60_flexbus.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_rtc.c MK60_sdhc.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_usb.c MK60_wdog.c vectors.c
    ../../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
  group LIB/FatFs
    ../../Lib/FatFs/: diskio.c ff.c
  group LIB/USB
    ../../Lib/USB/: USB.c USB_CDC.c
